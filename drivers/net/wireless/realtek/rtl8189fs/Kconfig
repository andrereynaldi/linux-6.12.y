## drivers/net/wireless/realtek/rtl8189fs/Kconfig
```kconfig
config RTL8189FS
	tristate "Realtek 8189F SDIO WiFi"
	depends on USB
	help
	  help message of RTL8189FS
```
